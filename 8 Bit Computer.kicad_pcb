# Repository The-Invent0r/8-bit-Computer-PCB (continued)

## KiCad design 8 Bit Computer.kicad_pcb (continued)

Parts:
C9, C10: 0.01uF; C_Disc_D4.3mm_W1.9mm_P5.00mm
C11, C12, C35, C36, C37: 0.1uF; C_Disc_D4.3mm_W1.9mm_P5.00mm
R30, R31, R32, R52: 1K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R51: 100K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R53: 10K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
SW1: SW_SPDT; SW_Slide_1P2T_CK_OS102011MS2Q
U6: 74LS08; DIP-14_W7.62mm_Socket_LongPads
U18: NE555P; DIP-8_W7.62mm_Socket_LongPads
U19: 74LS107; DIP-14_W7.62mm_Socket_LongPads
U20: 74LS273; DIP-20_W7.62mm_Socket_LongPads
U21: 28C16; DIP-24_W15.24mm_Socket_LongPads
U22: 74LS139; DIP-16_W7.62mm_Socket_LongPads
U23, U24, U25, U26: SM420561N; 7SegmentLED_LTS6760_LTS6780

Connections:
/ALU/BUS_0: U20.3 (D0); also elsewhere on the board
/ALU/BUS_1: U20.4 (D1); also elsewhere on the board
/ALU/BUS_2: U20.7 (D2); also elsewhere on the board
/ALU/BUS_3: U20.8 (D3); also elsewhere on the board
/ALU/BUS_4: U20.13 (D4); also elsewhere on the board
/ALU/BUS_5: U20.14 (D5); also elsewhere on the board
/ALU/BUS_6: U20.17 (D6); also elsewhere on the board
/ALU/BUS_7: U20.18 (D7); also elsewhere on the board
/ALU/CLK: U6.13; also elsewhere on the board
/Control_Logic/OI: U6.12; also elsewhere on the board
/Control_Logic/~CLR: U20.1 (~Mr); also elsewhere on the board
GND: C9.2, C10.2, C11.2, C12.2, C35.2, C36.2, C37.2, R53.2, U6.7 (GND), U18.1 (GND), U19.7 (GND), U20.10 (GND), U21.12 (GND), U21.18 (~CE), U21.20 (~OE), U22.8 (GND), U22.15 (E); also elsewhere on the board
unnamed: C9.1, R51.2, U18.2 (TR), U18.6 (THR)
unnamed: C10.1, U18.5 (CV)
unnamed: R30.1, U6.4, U6.5
unnamed: R31.1, U6.9, U6.10
unnamed: R32.1, U6.1, U6.2
unnamed: R51.1, R52.2, U18.7 (DIS)
unnamed: R53.1, SW1.1 (A)
unnamed: SW1.2 (B), U21.19 (A10)
unnamed: U18.3 (Q), U19.12 (C)
unnamed: U19.3 (Q), U19.9 (C), U21.22 (A9), U22.14 (A0)
unnamed: U19.5 (Q), U21.23 (A8), U22.13 (A1)
unnamed: U20.2 (Q0), U21.8 (A0)
unnamed: U20.5 (Q1), U21.7 (A1)
unnamed: U20.6 (Q2), U21.6 (A2)
unnamed: U20.9 (Q3), U21.5 (A3)
unnamed: U6.11, U20.11 (Cp)
unnamed: U20.12 (Q4), U21.4 (A4)
unnamed: U20.15 (Q5), U21.3 (A5)
unnamed: U20.16 (Q6), U21.2 (A6)
unnamed: U20.19 (Q7), U21.1 (A7)
unnamed: U21.9 (D0), U23.10 (G), U24.10 (G), U25.10 (G), U26.10 (G)
unnamed: U21.10 (D1), U23.9 (F), U24.9 (F), U25.9 (F), U26.9 (F)
unnamed: U21.11 (D2), U23.1 (E), U24.1 (E), U25.1 (E), U26.1 (E)
unnamed: U21.13 (D3), U23.2 (D), U24.2 (D), U25.2 (D), U26.2 (D)
unnamed: U21.14 (D4), U23.4 (C), U24.4 (C), U25.4 (C), U26.4 (C)
unnamed: U21.15 (D5), U23.6 (B), U24.6 (B), U25.6 (B), U26.6 (B)
unnamed: U21.16 (D6), U23.7 (A), U24.7 (A), U25.7 (A), U26.7 (A)
unnamed: U21.17 (D7), U23.5 (DP), U24.5 (DP), U25.5 (DP), U26.5 (DP)
unnamed: U22.9 (O3), U23.3 (CC), U23.8 (CC)
unnamed: U22.10 (O2), U25.3 (CC), U25.8 (CC)
unnamed: U22.11 (O1), U24.3 (CC), U24.8 (CC)
unnamed: U22.12 (O0), U26.3 (CC), U26.8 (CC)
VCC: C11.1, C12.1, C35.1, C36.1, C37.1, R30.2, R31.2, R32.2, R52.1, SW1.3 (C), U6.14 (VCC), U18.8 (VCC), U19.1 (J), U19.4 (K), U19.8 (J), U19.10 (~R), U19.11 (K), U19.13 (~R), U19.14 (VCC), U20.20 (VCC), U21.21 (~WE), U21.24 (VCC), U22.16 (VCC); also elsewhere on the board

Parts:
C13, C15, C16: 0.01uF; C_Disc_D4.3mm_W1.9mm_P5.00mm
C14: 1uF; CP_Radial_D5.0mm_P2.00mm
C17, C18, C19, C53: 0.1uF; C_Disc_D4.3mm_W1.9mm_P5.00mm
D39: BLUE; LED_D5.0mm
R54, R55, R56, R57, R58, R60, R61, R62, R63, R64, R65, R66: 1K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R59: 1M; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R67: 220; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
RV1: 1M; Potentiometer-5.5mm
SW2: SW_SPDT; SW_Slide_1P2T_CK_OS102011MS2Q
SW3: SW_Push; SW_PUSH_6mm_H5mm
U27, U28, U29: NE555P; DIP-8_W7.62mm
U30: 74LS32; DIP-14_W7.62mm_Socket_LongPads
U31: 74LS08; DIP-14_W7.62mm_Socket_LongPads
U32: 74LS04; DIP-14_W7.62mm_Socket_LongPads

Connections:
/ALU/CLK: D39.2 (A), U31.8, U32.13; also elsewhere on the board
/ClockModule/HLT: U32.9; also elsewhere on the board
/ClockModule/~CLK: U32.12; also elsewhere on the board
GND: C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C53.1, R67.2, SW2.2 (B), SW3.1, U27.1 (GND), U28.1 (GND), U29.1 (GND), U29.6 (THR), U30.7 (GND), U31.7 (GND), U32.7 (GND); also elsewhere on the board
unnamed: C13.1, U27.5 (CV)
unnamed: C14.1, RV1.1, U27.2 (TR), U27.6 (THR)
unnamed: C15.1, U28.5 (CV)
unnamed: C16.1, U29.5 (CV)
unnamed: C17.1, R59.2, U28.6 (THR), U28.7 (DIS)
unnamed: C53.2, R55.2, SW3.2, U28.2 (TR)
unnamed: D39.1 (K), R67.1
unnamed: R54.2, SW2.1 (A), U29.2 (TR)
unnamed: R56.2, SW2.3 (C), U29.4 (R)
unnamed: R57.2, R58.1, U27.7 (DIS)
unnamed: R58.2, RV1.2
unnamed: R60.1, U30.9, U30.10
unnamed: R61.1, U30.12, U30.13
unnamed: R62.1, U30.4, U30.5
unnamed: R63.1, U31.12, U31.13
unnamed: R64.1, U32.11
unnamed: R65.1, U32.3
unnamed: R66.1, U32.5
unnamed: U27.3 (Q), U31.1
unnamed: U28.3 (Q), U31.5
unnamed: U29.3 (Q), U31.2, U32.1
unnamed: U30.1, U31.3
unnamed: U30.2, U31.6
unnamed: U30.3, U31.9
unnamed: U31.4, U32.2
unnamed: U31.10, U32.8
VCC: C18.1, C19.1, R54.1, R55.1, R56.1, R57.1, R59.1, R60.2, R61.2, R62.2, R63.2, R64.2, R65.2, R66.2, U27.4 (R), U27.8 (VCC), U28.4 (R), U28.8 (VCC), U29.8 (VCC), U30.14 (VCC), U31.14 (VCC), U32.14 (VCC); also elsewhere on the board

Parts:
C20, C21: 0.1uF; C_Disc_D4.3mm_W1.9mm_P5.00mm
D40, D41, D42, D43: YELLOW; LED_D5.0mm
D44: RED; LED_D5.0mm
D45: GREEN; LED_D5.0mm
R68, R69, R70, R71: 220; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R72, R73: 1K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
SW4: SW_SPDT; SW_Slide_1P2T_CK_OS102011MS2Q
SW5: SW_DIP_x04; SW_DIP_SPSTx04_Slide_9.78x12.34mm_W7.62mm_P2.54mm
U33: 74LS157; DIP-16_W7.62mm_Socket_LongPads
U34: 74LS173; DIP-16_W7.62mm_Socket_LongPads

Connections:
/ALU/BUS_0: U34.11 (D3); also elsewhere on the board
/ALU/BUS_1: U34.12 (D2); also elsewhere on the board
/ALU/BUS_2: U34.13 (D1); also elsewhere on the board
/ALU/BUS_3: U34.14 (D0); also elsewhere on the board
/ALU/CLK: U34.7 (Cp); also elsewhere on the board
/Control_Logic/CLR: U34.15 (Mr); also elsewhere on the board
/Control_Logic/~MI: U34.9 (E1), U34.10 (E2); also elsewhere on the board
/MAR/A0: D43.2 (A), U33.9 (Zc); also elsewhere on the board
/MAR/A1: D42.2 (A), U33.12 (Zd); also elsewhere on the board
/MAR/A2: D41.2 (A), U33.7 (Zb); also elsewhere on the board
/MAR/A3: D40.2 (A), U33.4 (Za); also elsewhere on the board
/MAR/PROG: D44.1 (K), SW4.1 (A), U33.1 (S); also elsewhere on the board
GND: C20.2, C21.2, R68.2, R69.2, R70.2, R71.2, SW4.2 (B), SW5.3, SW5.4, SW5.7, SW5.8, U33.8 (GND), U33.15 (E), U34.1 (Oe1), U34.2 (Oe2), U34.8 (GND); also elsewhere on the board
unnamed: D40.1 (K), R68.1
unnamed: D41.1 (K), R69.1
unnamed: D42.1 (K), R70.1
unnamed: D43.1 (K), R71.1
unnamed: D44.2 (A), R72.2
unnamed: D45.1 (K), SW4.3 (C)
unnamed: D45.2 (A), R73.2
unnamed: SW5.1, U33.11 (I0c)
unnamed: SW5.2, U33.14 (I0d)
unnamed: SW5.5, U33.2 (I0a)
unnamed: SW5.6, U33.5 (I0b)
unnamed: U33.3 (I1a), U34.3 (Q0)
unnamed: U33.6 (I1b), U34.4 (Q1)
unnamed: U33.10 (I1c), U34.6 (Q3)
unnamed: U33.13 (I1d), U34.5 (Q2)
VCC: C20.1, C21.1, R72.1, R73.1, U33.16 (VCC), U34.16 (VCC); also elsewhere on the board

Schematic: InstructionRegister.sch

Parts:
C38, C39, C40: 0.1uF; C_Disc_D4.3mm_W1.9mm_P5.00mm
D46, D47, D48, D49: BLUE; LED_D5.0mm
D50, D51, D52, D53: YELLOW; LED_D5.0mm
R74, R75, R76, R77, R78, R79, R80, R81: 220; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
U35: 74LS245; DIP-20_W7.62mm_Socket_LongPads
U36, U37: 74LS173; DIP-16_W7.62mm_Socket_LongPads

Connections:
/ALU/BUS_0: U35.11 (B7), U37.11 (D3); also elsewhere on the board
/ALU/BUS_1: U35.12 (B6), U37.12 (D2); also elsewhere on the board
/ALU/BUS_2: U35.13 (B5), U37.13 (D1); also elsewhere on the board
/ALU/BUS_3: U35.14 (B4), U37.14 (D0); also elsewhere on the board
/ALU/BUS_4: U35.15 (B3), U36.11 (D3); also elsewhere on the board
/ALU/BUS_5: U35.16 (B2), U36.12 (D2); also elsewhere on the board
/ALU/BUS_6: U35.17 (B1), U36.13 (D1); also elsewhere on the board
/ALU/BUS_7: U35.18 (B0), U36.14 (D0); also elsewhere on the board
/ALU/CLK: U36.7 (Cp), U37.7 (Cp); also elsewhere on the board
/Control_Logic/CLR: U36.15 (Mr), U37.15 (Mr); also elsewhere on the board
/Control_Logic/IR_4: D49.2 (A), U36.6 (Q3); also elsewhere on the board
/Control_Logic/IR_5: D48.2 (A), U36.5 (Q2); also elsewhere on the board
/Control_Logic/IR_6: D47.2 (A), U36.4 (Q1); also elsewhere on the board
/Control_Logic/IR_7: D46.2 (A), U36.3 (Q0); also elsewhere on the board
/Control_Logic/~II: U36.9 (E1), U36.10 (E2), U37.9 (E1), U37.10 (E2); also elsewhere on the board
/Control_Logic/~IO: U35.19 (CE); also elsewhere on the board
GND: C38.2, C39.2, C40.2, R74.2, R75.2, R76.2, R77.2, R78.2, R79.2, R80.2, R81.2, U35.2 (A0), U35.3 (A1), U35.4 (A2), U35.5 (A3), U35.10 (GND), U36.1 (Oe1), U36.2 (Oe2), U36.8 (GND), U37.1 (Oe1), U37.2 (Oe2), U37.8 (GND); also elsewhere on the board
unnamed: D46.1 (K), R74.1
unnamed: D47.1 (K), R75.1
unnamed: D48.1 (K), R76.1
unnamed: D49.1 (K), R77.1
unnamed: D50.1 (K), R78.1
unnamed: D50.2 (A), U35.6 (A4), U37.3 (Q0)
unnamed: D51.1 (K), R79.1
unnamed: D51.2 (A), U35.7 (A5), U37.4 (Q1)
unnamed: D52.1 (K), R80.1
unnamed: D52.2 (A), U35.8 (A6), U37.5 (Q2)
unnamed: D53.1 (K), R81.1
unnamed: D53.2 (A), U35.9 (A7), U37.6 (Q3)
VCC: C38.1, C39.1, C40.1, U35.1 (A->B), U35.20 (VCC), U36.16 (VCC), U37.16 (VCC); also elsewhere on the board

Schematic: RAM.sch

Parts:
C24: 0.01uF; C_Disc_D4.3mm_W1.9mm_P5.00mm
C25, C26, C41, C42, C43, C44, C45, C46, C47: 0.1uF; C_Disc_D4.3mm_W1.9mm_P5.00mm
D54, D55, D56, D57, D58, D59, D60, D61: RED; LED_D5.0mm
R82, R83, R84, R85, R86, R87, R88, R89: 220; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R90: 1K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
SW6: SW_Push; SW_PUSH_6mm_H5mm
SW7: SW_DIP_x08; SW_DIP_SPSTx08_Slide_9.78x22.5mm_W7.62mm_P2.54mm
U38, U39: 74LS04; DIP-14_W7.62mm_Socket_LongPads
U40, U45, U46: 74LS157; DIP-16_W7.62mm_Socket_LongPads
U41, U44: 74189; DIP-16_W7.62mm_Socket_LongPads
U42: 74LS00; DIP-14_W7.62mm_Socket_LongPads
U43: 74LS245; DIP-20_W7.62mm_Socket_LongPads

Connections:
/ALU/BUS_0: U43.11 (B7), U46.10 (I1c); also elsewhere on the board
/ALU/BUS_1: U43.12 (B6), U46.13 (I1d); also elsewhere on the board
/ALU/BUS_2: U43.13 (B5), U46.6 (I1b); also elsewhere on the board
/ALU/BUS_3: U43.14 (B4), U46.3 (I1a); also elsewhere on the board
/ALU/BUS_4: U43.15 (B3), U45.10 (I1c); also elsewhere on the board
/ALU/BUS_5: U43.16 (B2), U45.13 (I1d); also elsewhere on the board
/ALU/BUS_6: U43.17 (B1), U45.6 (I1b); also elsewhere on the board
/ALU/BUS_7: U43.18 (B0), U45.3 (I1a); also elsewhere on the board
/ALU/CLK: C24.1; also elsewhere on the board
/Control_Logic/RI: U42.2; also elsewhere on the board
/Control_Logic/~RO: U43.19 (CE); also elsewhere on the board
/MAR/A0: U41.1 (A0), U44.1 (A0); also elsewhere on the board
/MAR/A1: U41.15 (A1), U44.15 (A1); also elsewhere on the board
/MAR/A2: U41.14 (A2), U44.14 (A2); also elsewhere on the board
/MAR/A3: U41.13 (A3), U44.13 (A3); also elsewhere on the board
/MAR/PROG: U40.1 (S), U45.1 (S), U46.1 (S); also elsewhere on the board
GND: C25.2, C26.2, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, R82.2, R83.2, R84.2, R85.2, R86.2, R87.2, R88.2, R89.2, R90.1, SW6.1, SW7.3, SW7.4, SW7.7, SW7.8, SW7.11, SW7.12, SW7.15, SW7.16, U38.7 (GND), U38.11, U38.13, U39.7 (GND), U39.9, U39.11, U40.8 (GND), U40.15 (E), U41.2 (~CS), U41.8 (GND), U42.4, U42.5, U42.7 (GND), U42.9, U42.10, U42.12, U42.13, U43.10 (GND), U44.2 (~CS), U44.8 (GND), U45.8 (GND), U45.15 (E), U46.8 (GND), U46.15 (E); also elsewhere on the board
unnamed: C24.2, R90.2, U42.1
unnamed: D54.1 (K), R82.1
unnamed: D54.2 (A), U38.2, U43.2 (A0)
unnamed: D55.1 (K), R83.1
unnamed: D55.2 (A), U38.4, U43.3 (A1)
unnamed: D56.1 (K), R84.1
unnamed: D56.2 (A), U38.6, U43.4 (A2)
unnamed: D57.1 (K), R85.1
unnamed: D57.2 (A), U38.8, U43.5 (A3)
unnamed: D58.1 (K), R86.1
unnamed: D58.2 (A), U39.12, U43.6 (A4)
unnamed: D59.1 (K), R87.1
unnamed: D59.2 (A), U39.2, U43.7 (A5)
unnamed: D60.1 (K), R88.1
unnamed: D60.2 (A), U39.4, U43.8 (A6)
unnamed: D61.1 (K), R89.1
unnamed: D61.2 (A), U39.6, U43.9 (A7)
unnamed: SW6.2, U40.14 (I0d)
unnamed: SW7.1, U46.11 (I0c)
unnamed: SW7.2, U46.14 (I0d)
unnamed: SW7.5, U45.11 (I0c)
unnamed: SW7.6, U45.14 (I0d)
unnamed: SW7.9, U45.2 (I0a)
unnamed: SW7.10, U45.5 (I0b)
unnamed: SW7.13, U46.2 (I0a)
unnamed: SW7.14, U46.5 (I0b)
unnamed: U38.1, U41.5 (~O1)
unnamed: U38.3, U41.7 (~O2)
unnamed: U38.5, U41.9 (~O3)
unnamed: U38.9, U41.11 (~O4)
unnamed: U39.1, U44.9 (~O3)
unnamed: U39.3, U44.7 (~O2)
unnamed: U39.5, U44.5 (~O1)
unnamed: U39.13, U44.11 (~O4)
unnamed: U40.12 (Zd), U41.3 (~WE), U44.3 (~WE)
unnamed: U40.13 (I1d), U42.3
unnamed: U41.4 (D1), U45.4 (Za)
unnamed: U41.6 (D2), U45.7 (Zb)
unnamed: U41.10 (D3), U45.12 (Zd)
unnamed: U41.12 (D4), U45.9 (Zc)
unnamed: U44.4 (D1), U46.9 (Zc)
unnamed: U44.6 (D2), U46.12 (Zd)
unnamed: U44.10 (D3), U46.7 (Zb)
unnamed: U44.12 (D4), U46.4 (Za)
VCC: C25.1, C26.1, C41.1, C42.1, C43.1, C44.1, C45.1, C46.1, C47.1, U38.14 (VCC), U39.14 (VCC), U40.16 (VCC), U41.16 (VCC), U42.14 (VCC), U43.1 (A->B), U43.20 (VCC), U44.16 (VCC), U45.16 (VCC), U46.16 (VCC); also elsewhere on the board

Schematic: Control_Logic.sch

Parts:
C27, C28, C48, C49, C50, C51, C52: 0.1uF; C_Disc_D4.3mm_W1.9mm_P5.00mm
D62, D63, D64, D65, D66: GREEN; LED_D5.0mm
D67, D68, D69: RED; LED_D5.0mm
D70, D71, D72, D73, D74, D75, D76, D77, D78, D79, D80, D81, D82, D83, D84, D85: BLUE; LED_D5.0mm
R91: 1K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R92, R93, R94, R95, R96, R97, R98, R99, R100, R101, R102, R103, R104, R105, R106, R107, R108, R109, R110, R111, R112, R113, R114, R115: 220; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
SW8: RESET; SW_PUSH_6mm_H5mm
U47: 74LS00; DIP-14_W7.62mm_Socket_LongPads
U48: 74LS161; DIP-16_W7.62mm_Socket_LongPads
U49: 74LS138; DIP-16_W7.62mm_Socket_LongPads
U50, U51: 28C16; DIP-24_W15.24mm_Socket_LongPads
U52, U53: 74LS04; DIP-14_W7.62mm_Socket_LongPads

Connections:
/ALU/CF: U50.23 (A8), U51.23 (A8); also elsewhere on the board
/ALU/SU: D79.2 (A), U51.16 (D6); also elsewhere on the board
/ALU/ZF: U50.22 (A9), U51.22 (A9); also elsewhere on the board
/ALU/~EO: U53.2; also elsewhere on the board
/ALU/~FI: U53.6; also elsewhere on the board
/A_Register/~AI: U52.10; also elsewhere on the board
/A_Register/~AO: U52.8; also elsewhere on the board
/B_Register/~BI: U53.4; also elsewhere on the board
/ClockModule/HLT: D70.2 (A), U50.17 (D7); also elsewhere on the board
/ClockModule/~CLK: U48.2 (CP); also elsewhere on the board
/Control_Logic/CE: D82.2 (A), U51.13 (D3); also elsewhere on the board
/Control_Logic/CLR: U47.11; also elsewhere on the board
/Control_Logic/IR_4: U50.5 (A3), U51.5 (A3); also elsewhere on the board
/Control_Logic/IR_5: U50.4 (A4), U51.4 (A4); also elsewhere on the board
/Control_Logic/IR_6: U50.3 (A5), U51.3 (A5); also elsewhere on the board
/Control_Logic/IR_7: U50.2 (A6), U51.2 (A6); also elsewhere on the board
/Control_Logic/OI: D81.2 (A), U51.14 (D4); also elsewhere on the board
/Control_Logic/RI: D72.2 (A), U50.15 (D5); also elsewhere on the board
/Control_Logic/~CLR: U47.4, U47.8, U47.12, U47.13; also elsewhere on the board
/Control_Logic/~CO: U53.12; also elsewhere on the board
/Control_Logic/~II: U52.12; also elsewhere on the board
/Control_Logic/~IO: U52.6; also elsewhere on the board
/Control_Logic/~J: U53.10; also elsewhere on the board
/Control_Logic/~MI: U52.2; also elsewhere on the board
/Control_Logic/~RO: U52.4; also elsewhere on the board
GND: C27.2, C28.2, C48.2, C49.2, C50.2, C51.2, C52.2, R91.1, R97.2, R98.2, R99.2, R100.2, R101.2, R102.2, R103.2, R104.2, R105.2, R106.2, R107.2, R108.2, R109.2, R110.2, R111.2, R112.2, R113.2, R114.2, R115.2, U47.7 (GND), U48.8 (GND), U49.4 (E1), U49.5 (E2), U49.8 (GND), U50.1 (A7), U50.12 (GND), U50.18 (~CE), U50.19 (A10), U50.20 (~OE), U51.12 (GND), U51.18 (~CE), U51.19 (A10), U51.20 (~OE), U52.7 (GND), U53.7 (GND), U53.9; also elsewhere on the board
unnamed: D62.1 (K), U49.11 (O4)
unnamed: D62.2 (A), R92.2
unnamed: D63.1 (K), U49.12 (O3)
unnamed: D63.2 (A), R93.2
unnamed: D64.1 (K), U49.13 (O2)
unnamed: D64.2 (A), R94.2
unnamed: D65.1 (K), U49.14 (O1)
unnamed: D65.2 (A), R95.2
unnamed: D66.1 (K), U49.15 (O0)
unnamed: D66.2 (A), R96.2
unnamed: D67.1 (K), R97.1
unnamed: D67.2 (A), U48.14 (Q0), U49.1 (A0), U50.8 (A0), U51.8 (A0)
unnamed: D68.1 (K), R98.1
unnamed: D68.2 (A), U48.13 (Q1), U49.2 (A1), U50.7 (A1), U51.7 (A1)
unnamed: D69.1 (K), R99.1
unnamed: D69.2 (A), U48.12 (Q2), U49.3 (A2), U50.6 (A2), U51.6 (A2)
unnamed: D70.1 (K), R100.1
unnamed: D71.1 (K), R101.1
unnamed: D71.2 (A), U50.16 (D6), U52.1
unnamed: D72.1 (K), R102.1
unnamed: D73.1 (K), R103.1
unnamed: D73.2 (A), U50.14 (D4), U52.3
unnamed: D74.1 (K), R104.1
unnamed: D74.2 (A), U50.13 (D3), U52.5
unnamed: D75.1 (K), R105.1
unnamed: D75.2 (A), U50.11 (D2), U52.13
unnamed: D76.1 (K), R106.1
unnamed: D76.2 (A), U50.10 (D1), U52.11
unnamed: D77.1 (K), R107.1
unnamed: D77.2 (A), U50.9 (D0), U52.9
unnamed: D78.1 (K), R108.1
unnamed: D78.2 (A), U51.17 (D7), U53.1
unnamed: D79.1 (K), R109.1
unnamed: D80.1 (K), R110.1
unnamed: D80.2 (A), U51.15 (D5), U53.3
unnamed: D81.1 (K), R111.1
unnamed: D82.1 (K), R112.1
unnamed: D83.1 (K), R113.1
unnamed: D83.2 (A), U51.11 (D2), U53.13
unnamed: D84.1 (K), R114.1
unnamed: D84.2 (A), U51.10 (D1), U53.11
unnamed: D85.1 (K), R115.1
unnamed: D85.2 (A), U51.9 (D0), U53.5
unnamed: R91.2, SW8.1, U47.9, U47.10
unnamed: U47.1, U47.2, U47.6
unnamed: U47.3, U48.1 (~MR)
unnamed: U47.5, U49.10 (O5)
VCC: C27.1, C28.1, C48.1, C49.1, C50.1, C51.1, C52.1, R92.1, R93.1, R94.1, R95.1, R96.1, SW8.2, U47.14 (VCC), U48.7 (CEP), U48.9 (~PE), U48.10 (CET), U48.16 (VCC), U49.6 (E3), U49.16 (VCC), U50.21 (~WE), U50.24 (VCC), U51.1 (A7), U51.21 (~WE), U51.24 (VCC), U52.14 (VCC), U53.14 (VCC); also elsewhere on the board

Board: 2 copper layers, 370.8 x 298.4 mm, 319 parts (0 on the bottom side), 304 nets.
